# IAR project RZN2L_RSK_lwIP_single.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R9A07G084M04 Renesas R9A07G084M04
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 49
  General.FPU2: 8
  ICCARM.CCDefines: _LWIP_ADD_ON_APP=0; _RZN_ORDINAL=1; _RZN_CORE=CR52_0; _RENESAS_RZN_
  ICCARM.CCIncludePath2: rzn/arm/CMSIS_5/CMSIS/Core_R/Include; rzn/aws/amazon-freertos/freertos_kernel/include; rzn/fsp/inc; rzn/fsp/inc/api; rzn/fsp/inc/instances; rzn/fsp/src/bsp/mcu/all/cr; rzn/fsp/src/rm_freertos_port/cr; rzn_cfg/aws; rzn_cfg/fsp_cfg; rzn_cfg/fsp_cfg/bsp; rzn_gen; src; $PROJ_DIR$; ..\..\..\..\common\oss\amazon-freertos\libraries\3rdparty\lwip_osal\include; ..\..\..\..\common\oss\lwip\src\include; ..\..\..\..\common\renesas\module; ..\..\..\..\common\renesas\module\ether_netif; ..\..\..\..\common\renesas\module\lwip_port; ..\..\..\..\common\renesas\module\serial_io; ..\..\..\..\common\renesas\oss_deps\lwip
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _RZN_ORDINAL=1; _RZN_CORE=CR52_0; _RENESAS_RZN_
  AARM.AUserIncludes: rzn/arm/CMSIS_5/CMSIS/Core_R/Include; rzn/aws/amazon-freertos/freertos_kernel/include; rzn/fsp/inc; rzn/fsp/inc/api; rzn/fsp/inc/instances; rzn/fsp/src/bsp/mcu/all/cr; rzn/fsp/src/rm_freertos_port/cr; rzn_cfg/aws; rzn_cfg/fsp_cfg; rzn_cfg/fsp_cfg/bsp; rzn_gen; src; $PROJ_DIR$
  OBJCOPY.OOCOutputFile: RZN2L_RSK_lwIP_single.srec
  ILINK.IlinkOutputFile: RZN2L_RSK_lwIP_single.out
  ILINK.IlinkIcfFile: script/fsp_ram_execution.icf
  ILINK.IlinkExtraOptions: --config_search "$PROJ_DIR$"
  ILINK.IlinkProgramEntryLabel: system_init
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; _RZN_ORDINAL=1; _RZN_CORE=CR52_0; _RENESAS_RZN_
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  group (top)
    ./: buildinfo.ipcf
  group common/oss/amazon-freertos/libraries
    ../../../../common/oss/amazon-freertos/: LICENSE
  group common/oss/amazon-freertos/libraries/3rdparty/lwip_osal/include
    ../../../../common/oss/amazon-freertos/libraries/3rdparty/lwip_osal/include/: lwipopts_freertos.h
  group common/oss/amazon-freertos/libraries/3rdparty/lwip_osal/include/arch
    ../../../../common/oss/amazon-freertos/libraries/3rdparty/lwip_osal/include/arch/: cc.h perf.h sys_arch.h
  group common/oss/amazon-freertos/libraries/3rdparty/lwip_osal/src
    ../../../../common/oss/amazon-freertos/libraries/3rdparty/lwip_osal/src/: sys_arch.c
  group common/oss/lwip
    ../../../../common/oss/lwip/: COPYING
  group common/oss/lwip/src
    ../../../../common/oss/lwip/src/: Filelists.cmake Filelists.mk FILES
  group common/oss/lwip/src/api
    ../../../../common/oss/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group common/oss/lwip/src/apps/lwperf
    ../../../../common/oss/lwip/src/apps/lwiperf/: lwiperf.c
  group common/oss/lwip/src/apps/sntp
    ../../../../common/oss/lwip/src/apps/sntp/: sntp.c
  group common/oss/lwip/src/core
    ../../../../common/oss/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group common/oss/lwip/src/core/ipv4
    ../../../../common/oss/lwip/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group common/oss/lwip/src/core/ipv6
    ../../../../common/oss/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group common/oss/lwip/src/include/compat/posix
    ../../../../common/oss/lwip/src/include/compat/posix/: netdb.h
  group common/oss/lwip/src/include/compat/posix/arpa
    ../../../../common/oss/lwip/src/include/compat/posix/arpa/: inet.h
  group common/oss/lwip/src/include/compat/posix/net
    ../../../../common/oss/lwip/src/include/compat/posix/net/: if.h
  group common/oss/lwip/src/include/compat/posix/sys
    ../../../../common/oss/lwip/src/include/compat/posix/sys/: socket.h
  group common/oss/lwip/src/include/compat/stdc
    ../../../../common/oss/lwip/src/include/compat/stdc/: errno.h
  group common/oss/lwip/src/include/lwip
    ../../../../common/oss/lwip/src/include/lwip/: acd.h altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h init.h.cmake.in ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group common/oss/lwip/src/include/lwip/apps
    ../../../../common/oss/lwip/src/include/lwip/apps/: altcp_proxyconnect.h altcp_tls_mbedtls_opts.h FILES fs.h http_client.h httpd.h httpd_opts.h lwiperf.h mdns.h mdns_domain.h mdns_opts.h mdns_out.h mdns_priv.h mqtt.h mqtt_opts.h mqtt_priv.h netbiosns.h netbiosns_opts.h smtp.h smtp_opts.h snmp.h snmp_core.h snmp_mib2.h snmp_opts.h snmp_scalar.h snmp_snmpv2_framework.h snmp_snmpv2_usm.h snmp_table.h snmp_threadsync.h snmpv3.h sntp.h sntp_opts.h tftp_client.h tftp_common.h tftp_opts.h tftp_server.h
  group common/oss/lwip/src/include/lwip/priv
    ../../../../common/oss/lwip/src/include/lwip/priv/: altcp_priv.h api_msg.h mem_priv.h memp_priv.h memp_std.h nd6_priv.h raw_priv.h sockets_priv.h tcp_priv.h tcpip_priv.h
  group common/oss/lwip/src/include/lwip/priv
    ../../../../common/oss/lwip/src/include/lwip/prot/: acd.h autoip.h dhcp.h dhcp6.h dns.h etharp.h ethernet.h iana.h icmp.h icmp6.h ieee.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group common/oss/lwip/src/include/netif
    ../../../../common/oss/lwip/src/include/netif/: bridgeif.h bridgeif_opts.h etharp.h ethernet.h ieee802154.h lowpan6.h lowpan6_ble.h lowpan6_common.h lowpan6_opts.h slipif.h zepif.h
  group common/oss/lwip/src/include/netif/ppp
    ../../../../common/oss/lwip/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group common/oss/lwip/src/include/netif/ppp/polassl
    ../../../../common/oss/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group common/oss/lwip/src/netif
    ../../../../common/oss/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c FILES lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group common/oss/lwip/src/netif/ppp
    ../../../../common/oss/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c PPPD_FOLLOWUP pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group common/oss/lwip/src/netif/ppp/polarssl
    ../../../../common/oss/lwip/src/netif/ppp/polarssl/: arc4.c des.c md4.c md5.c README sha1.c
  group common/renesas/application
    ../../../../common/renesas/application/: lwip_add_on_main.c lwip_port_instance.c lwip_port_main.c
  group common/renesas/module
    ../../../../common/renesas/module/: um_common_api.h um_common_cfg.h
  group common/renesas/module/ether_netif
    ../../../../common/renesas/module/ether_netif/: um_ether_netif.c um_ether_netif.h um_ether_netif_api.h um_ether_netif_callback.c um_ether_netif_cfg.h um_ether_netif_ether.c um_ether_netif_feature.h um_ether_netif_internal.h um_ether_netif_task_monitor.c um_ether_netif_task_reader.c
  group common/renesas/module/lwip_port
    ../../../../common/renesas/module/lwip_port/: um_lwip_port.c um_lwip_port.h um_lwip_port_api.h um_lwip_port_callback.c um_lwip_port_cfg.h um_lwip_port_core.c um_lwip_port_ether_netif.c um_lwip_port_internal.h um_lwip_port_netif.c um_lwip_port_netif_list.c um_lwip_port_task_launcher.c
  group common/renesas/module/serial_io
    ../../../../common/renesas/module/serial_io/: um_serial_io_api.h um_serial_io_cfg.h um_serial_io_uart.c
  group common/renesas/oss_deps/lwip
    ../../../../common/renesas/oss_deps/lwip/: lwipopts.h lwippools.h
  group Flex Software/Build Configuration
    rzn_cfg/fsp_cfg/bsp/: board_cfg.h bsp_cfg.h bsp_mcu_device_cfg.h bsp_mcu_device_memory_cfg.h bsp_mcu_device_pn_cfg.h bsp_mcu_family_cfg.h bsp_memory_cfg.h bsp_pin_cfg.h
    rzn_cfg/aws/: FreeRTOSConfig.h
    rzn_cfg/fsp_cfg/: r_ether_cfg.h r_ether_phy_cfg.h r_ether_selector_cfg.h r_ether_switch_cfg.h r_ioport_cfg.h r_rtc_cfg.h r_sci_uart_cfg.h
  group Flex Software/Components
    rzn/aws/amazon-freertos/freertos_kernel/include/: atomic.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h
    rzn/board/rzn2l_rsk/: board.h board_ethernet_phy.h board_init.c board_init.h board_leds.c board_leds.h
    rzn/fsp/inc/api/: bsp_api.h r_ether_api.h r_ether_phy_api.h r_ether_selector_api.h r_ether_switch_api.h r_ioport_api.h r_rtc_api.h r_transfer_api.h r_uart_api.h
    rzn/fsp/src/bsp/mcu/all/: bsp_cache.c bsp_cache.h bsp_clocks.c bsp_clocks.h bsp_common.c bsp_common.h bsp_compiler_support.h bsp_delay.c bsp_delay.h bsp_exceptions.h bsp_io.c bsp_io.h bsp_irq.c bsp_irq.h bsp_mcu_api.h bsp_module_stop.h bsp_register_protection.c bsp_register_protection.h bsp_reset.c bsp_reset.h bsp_sbrk.c bsp_tfu.h
    rzn/fsp/src/bsp/mcu/all/cr/: bsp_cache_core.c bsp_cache_core.h bsp_delay_core.c bsp_delay_core.h bsp_irq_core.c bsp_irq_core.h
    rzn/fsp/src/bsp/mcu/rzn2l/: bsp_elc.h bsp_feature.h bsp_irq_sense.c bsp_loader_param.c bsp_mcu_info.h bsp_override.h
    rzn/arm/CMSIS_5/CMSIS/Core_R/Include/: cmsis_compiler.h cmsis_cp15.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cr52.h
    rzn/aws/amazon-freertos/freertos_kernel/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    rzn/fsp/inc/: fsp_common_api.h fsp_features.h fsp_version.h
    rzn/aws/amazon-freertos/freertos_kernel/portable/MemMang/: heap_4.c
    rzn/aws/amazon-freertos/: LICENSE
    rzn/arm/CMSIS_5/: LICENSE.txt
    rzn/aws/amazon-freertos/freertos_kernel/License/: license.txt
    rzn/fsp/src/rm_freertos_port/cr/: port.c portmacro.h
    rzn/fsp/src/bsp/cmsis/Device/RENESAS/Include/: R9A07G084.h renesas.h system.h
    rzn/fsp/src/r_ether_phy/: r_ether_phy.c
    rzn/fsp/inc/instances/: r_ether_phy.h r_ether_selector.h r_ethsw.h r_gmac.h r_ioport.h r_rtc.h r_sci_uart.h
    rzn/fsp/src/r_ether_selector/: r_ether_selector.c
    rzn/fsp/src/r_ethsw/: r_ethsw.c
    rzn/fsp/src/r_gmac/: r_gmac.c
    rzn/fsp/src/r_ioport/: r_ioport.c
    rzn/fsp/src/r_rtc/: r_rtc.c
    rzn/fsp/src/r_sci_uart/: r_sci_uart.c
    rzn/fsp/src/bsp/cmsis/Device/RENESAS/Source/: startup.c system.c
    rzn/fsp/src/bsp/cmsis/Device/RENESAS/Source/cr/: startup_core.c system_core.c
  group Flex Software/Generated Data
    rzn_gen/: bsp_clock_cfg.h common_data.c common_data.h hal_data.c hal_data.h main.c main_thread.c main_thread.h pin_data.c vector_data.c vector_data.h
  group Flex Software/Program Entry
    src/: hal_entry.c main_thread_entry.c
